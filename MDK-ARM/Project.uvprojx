# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F072xB Puya
  pack: Puya.PY32F0xx_DFP.1.1.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F072xB
  c include: ..\Inc;..\Drivers\BSP\PY32F072xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F072\Include;..\Drivers\PY32F072_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ./: startup_py32f072xx.s
    ../Src/: system_py32f072.c
  group Application/User
    ../Src/: main.c py32f072_hal_msp.c py32f072_it.c uartHMI.c record.c task.c userApp.c key.c heater.c
  group Application/Motor
    ../Src/: FOC2R.c PLL.c PuyaMath.c
  group Drivers/PY32F072_HAL_Driver
    ../Drivers/PY32F072_HAL_Driver/Src/: py32f072_hal.c py32f072_hal_adc.c py32f072_hal_adc_ex.c py32f072_hal_tim.c py32f072_hal_tim_ex.c py32f072_hal_opa.c py32f072_hal_opa_ex.c py32f072_hal_comp.c py32f072_hal_div.c py32f072_hal_flash.c
    ../drivers/PY32F072_HAL_Driver/src/: py32f072_hal_rcc.c py32f072_hal_rcc_ex.c py32f072_hal_gpio.c py32f072_hal_dma.c py32f072_hal_pwr.c py32f072_hal_uart.c py32f072_hal_cortex.c
